# Keil uVision project cleaner_bk2.uvproj, settings and files
target cleaner (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: cleaner +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group AiCube
    ./Sources/: main.c port.c adc.c pwm.c usblib.c
    ./Sources/lib/: stc_usb_cdc_8h_xdata_bl51.lib
